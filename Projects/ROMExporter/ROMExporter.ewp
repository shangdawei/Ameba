# IAR project ROMExporter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RTL8195AM RTL8195AM
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: ..\..\Config\RTL8195AM_ROM.bat "$PROJ_DIR$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: rtl8195am_rom.out
  ILINK.IlinkIcfFile: ..\..\Config\RTL8195AM_ROM.icf
  ILINK.IlinkExtraOptions: --whole_archive ..\..\Common\MCU\rtl8195am_rom.a; --no_remove
  ILINK.IlinkProgramEntryLabel: __dummy_entry__
  group (top)
    ../../Common/MCU/: rtl8195am_rom.c
  group Config
    ../../Config/: RTL8195AM_ROM.bat RTL8195AM_ROM.icf RTL8195AM_ROM.txt
