# IAR project Application.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: RTL8195AM RTL8195AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Config; MCU; Source; \RTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Config
  prebuild: CSCRIPT "Config\RTL8195AM_PreBuild.vbs" "$PROJ_DIR$" "$PROJ_PATH$" "$CONFIG_NAME$"
  postbuild: CSCRIPT "Config\RTL8195AM_PostBuild.vbs" "$PROJ_DIR$" "$TARGET_PATH$" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: MCU\rtl8195am_rom.sym
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: GEN_IMAGE=1
  group Bootloader
    Bootloader/: main.c
  group Config
    Config/: IAR_AARM_Define.h IAR_CSPY_Parameters.mac IAR_ICCARM_Define.h IAR_ILINK_Parameters.icf RTL8195AM.icf RTL8195AM.mac RTL8195AM_PostBuild.vbs RTL8195AM_PreBuild.vbs RTL8195AM_SDRAM.mac
  group MCU
    MCU/: rtl8195am.h rtl8195am_adc.c rtl8195am_adc.h rtl8195am_compiler.h rtl8195am_conf.h rtl8195am_crypto.c rtl8195am_crypto.h rtl8195am_dac.c rtl8195am_dac.h rtl8195am_define.h rtl8195am_efuse.c rtl8195am_efuse.h rtl8195am_extra.h rtl8195am_gdma.c rtl8195am_gdma.h rtl8195am_gpio.c rtl8195am_gpio.h rtl8195am_gspi.c rtl8195am_gspi.h rtl8195am_i2c.c rtl8195am_i2c.h rtl8195am_i2s.c rtl8195am_i2s.h rtl8195am_irq.c rtl8195am_irq.h rtl8195am_log_uart.c rtl8195am_log_uart.h rtl8195am_mii.c rtl8195am_mii.h rtl8195am_misc.c rtl8195am_misc.h rtl8195am_nfc.c rtl8195am_nfc.h rtl8195am_pcm.c rtl8195am_pcm.h rtl8195am_peri_on.c rtl8195am_peri_on.h rtl8195am_pinmux.c rtl8195am_pinmux.h rtl8195am_platform.h rtl8195am_pwm.c rtl8195am_pwm.h rtl8195am_rom.out rtl8195am_rom.sym rtl8195am_rtos.c rtl8195am_rtos.h rtl8195am_sdio.c rtl8195am_sdio.h rtl8195am_sdio_host.c rtl8195am_sdio_host.h rtl8195am_sdr.c rtl8195am_sdr.h rtl8195am_sdr_controller.c rtl8195am_sdr_controller.h rtl8195am_spi_flash.c rtl8195am_spi_flash.h rtl8195am_spic.c rtl8195am_spic.h rtl8195am_ssi.c rtl8195am_ssi.h rtl8195am_sys_on.c rtl8195am_sys_on.h rtl8195am_timer.c rtl8195am_timer.h rtl8195am_types.h rtl8195am_uart.c rtl8195am_uart.h rtl8195am_usb.c rtl8195am_usb.h rtl8195am_util.c rtl8195am_util.h rtl8195am_wdt.c rtl8195am_wdt.h rtl8195am_wifi.c rtl8195am_wifi.h startup_RTL8195AM.s system_rtl8195am.c system_rtl8195am.h
  group RTOS
    RTOS/: cmsis_compiler.h cmsis_os2.h core_cm.h core_cm_ICCARM.h EventRecorder.h EventRecorderConf.h irq_cm3.s RTX_Config.c RTX_Config.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_evr.h rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_os.h rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c svc_user.c tz_context.h
